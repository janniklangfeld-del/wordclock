#include "intro.h"

namespace {
// Reihenfolge: ' ' ! - . 0-9 A-Z Ä Ö Ü Herz
const uint8_t FONT[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00},  // ' '
    {0x00, 0x00, 0x5F, 0x00, 0x00},  // !
    {0x08, 0x08, 0x08, 0x08, 0x08},  // -
    {0x00, 0x60, 0x60, 0x00, 0x00},  // .
    {0x3E, 0x51, 0x49, 0x45, 0x3E},  // 0
    {0x00, 0x42, 0x7F, 0x40, 0x00},  // 1
    {0x42, 0x61, 0x51, 0x49, 0x46},  // 2
    {0x21, 0x41, 0x45, 0x4B, 0x31},  // 3
    {0x18, 0x14, 0x12, 0x7F, 0x10},  // 4
    {0x27, 0x45, 0x45, 0x45, 0x39},  // 5
    {0x3C, 0x4A, 0x49, 0x49, 0x30},  // 6
    {0x01, 0x71, 0x09, 0x05, 0x03},  // 7
    {0x36, 0x49, 0x49, 0x49, 0x36},  // 8
    {0x06, 0x49, 0x49, 0x29, 0x1E},  // 9
    {0x7E, 0x11, 0x11, 0x11, 0x7E},  // A
    {0x7F, 0x49, 0x49, 0x49, 0x36},  // B
    {0x3E, 0x41, 0x41, 0x41, 0x22},  // C
    {0x7F, 0x41, 0x41, 0x22, 0x1C},  // D
    {0x7F, 0x49, 0x49, 0x49, 0x41},  // E
    {0x7F, 0x09, 0x09, 0x09, 0x01},  // F
    {0x3E, 0x41, 0x49, 0x49, 0x7A},  // G
    {0x7F, 0x08, 0x08, 0x08, 0x7F},  // H
    {0x00, 0x41, 0x7F, 0x41, 0x00},  // I
    {0x20, 0x40, 0x41, 0x3F, 0x01},  // J
    {0x7F, 0x08, 0x14, 0x22, 0x41},  // K
    {0x7F, 0x40, 0x40, 0x40, 0x40},  // L
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},  // M
    {0x7F, 0x04, 0x08, 0x10, 0x7F},  // N
    {0x3E, 0x41, 0x41, 0x41, 0x3E},  // O
    {0x7F, 0x09, 0x09, 0x09, 0x06},  // P
    {0x3E, 0x41, 0x51, 0x21, 0x5E},  // Q
    {0x7F, 0x09, 0x19, 0x29, 0x46},  // R
    {0x46, 0x49, 0x49, 0x49, 0x31},  // S
    {0x01, 0x01, 0x7F, 0x01, 0x01},  // T
    {0x3F, 0x40, 0x40, 0x40, 0x3F},  // U
    {0x1F, 0x20, 0x40, 0x20, 0x1F},  // V
    {0x3F, 0x40, 0x38, 0x40, 0x3F},  // W
    {0x63, 0x14, 0x08, 0x14, 0x63},  // X
    {0x07, 0x08, 0x70, 0x08, 0x07},  // Y
    {0x61, 0x51, 0x49, 0x45, 0x43},  // Z
    {0x7D, 0x12, 0x11, 0x12, 0x7D},  // Ä
    {0x3D, 0x42, 0x42, 0x42, 0x3D},  // Ö
    {0x3D, 0x40, 0x40, 0x40, 0x3D},  // Ü
    {0x0C, 0x1E, 0x3C, 0x1E, 0x0C},  // Herz
};
constexpr int G_SPACE = 0, G_EXCL = 1, G_DASH = 2, G_DOT = 3, G_DIGIT = 4, G_A = 14, G_AE = 40, G_OE = 41,
              G_UE = 42, G_HEART = 43;
}  // namespace

namespace intro {

int toColumns(const String& text, uint8_t* cols, int maxCols) {
  int n = 0;
  auto put = [&](int g) {
    for (int k = 0; k < 5 && n < maxCols; k++) cols[n++] = FONT[g][k];
    if (n < maxCols) cols[n++] = 0;
  };
  const uint8_t* s = (const uint8_t*)text.c_str();
  for (size_t i = 0; s[i];) {
    uint8_t c = s[i];
    int g = G_SPACE;
    size_t len = 1;
    if (c == '<' && s[i + 1] == '3') { g = G_HEART; len = 2; }
    else if (c == 0xE2 && s[i + 1] == 0x99 && s[i + 2] == 0xA5) { g = G_HEART; len = 3; }  // ♥
    else if (c == 0xE2 && s[i + 1] == 0x9D && s[i + 2] == 0xA4) { g = G_HEART; len = 3; }  // ❤
    else if (c == 0xC3 && s[i + 1]) {
      uint8_t d = s[i + 1] | 0x20;  // klein -> gleich behandeln
      len = 2;
      if (d == 0xA4) g = G_AE;
      else if (d == 0xB6) g = G_OE;
      else if (d == 0xBC) g = G_UE;
      else if (s[i + 1] == 0x9F) { put(G_A + ('S' - 'A')); g = G_A + ('S' - 'A'); }  // ß -> SS
    } else if (c >= 0x80) {  // anderes Mehrbyte-Zeichen ueberspringen
      len = 1;
      while ((s[i + len] & 0xC0) == 0x80) len++;
    } else {
      c = toupper(c);
      if (c >= 'A' && c <= 'Z') g = G_A + (c - 'A');
      else if (c >= '0' && c <= '9') g = G_DIGIT + (c - '0');
      else if (c == '!') g = G_EXCL;
      else if (c == '-') g = G_DASH;
      else if (c == '.') g = G_DOT;
    }
    put(g);
    i += len;
  }
  return n;
}

}  // namespace intro
